options:
  parameters:
    generate_options: qt_gui
    id: ofdm_tx_grc
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: base_group_delay
  id: variable_qtgui_range
  parameters:
    min_len: '10'
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '10'
  states: {}
- name: diff_group_delay
  id: variable_qtgui_range
  parameters:
    min_len: '10'
    rangeType: int
    start: '-3'
    step: '1'
    stop: '3'
    value: '-1'
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '1206'
  states: {}
- name: f_s
  id: variable
  parameters:
    value: '64'
  states: {}
- name: interp_factor
  id: variable
  parameters:
    value: '2'
  states: {}
- name: noise_pad_factor
  id: variable
  parameters:
    value: '2'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rrc_taps_ch0
  id: variable
  parameters:
    value: (2*base_group_delay)+1
  states: {}
- name: rrc_taps_ch1
  id: variable
  parameters:
    value: 2*(base_group_delay+1*diff_group_delay)+1
  states: {}
- name: rrc_taps_ch2
  id: variable
  parameters:
    value: 2*(base_group_delay+2*diff_group_delay)+1
  states: {}
- name: rrc_taps_ch3
  id: variable
  parameters:
    value: 2*(base_group_delay+3*diff_group_delay)+1
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: f_s
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '2'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '3'
    type: complex
  states: {}
- name: analog_noise_source_x_0_1
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '1'
    type: complex
  states: {}
- name: analog_noise_source_x_0_1_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_c
    offset: '0'
    phase: '0'
    samp_rate: f_s
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_2
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (packet_len*f_s, noise_pad_factor*packet_len*f_s)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '50'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: range(0,50)
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: f_s
    header_mod: '"QPSK"'
    occupied_carriers: '[list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27))]'
    packet_len_key: packet_len
    payload_mod: '"QPSK"'
    pilot_carriers: ((-21, -7, 7, 21,),)
    pilot_symbols: |-
      tuple((x, x, x, -x) for x in (1, 1, 1, 1, -1, -1, -1, 1, -1, -1, -1, -1, 1, 1, -1, 1, -1, -1, 1, 1, -1, 1, 1, -1, 1, 1, 1, 1, 1, 1, -1, 1,
      	1, 1, -1, 1, 1, -1, -1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, 1, -1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1,
      	-1, -1, 1, -1, 1, -1, 1, 1, -1, -1, -1, 1, 1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 1, 1, 1, 1, -1, 1, -1, 1, -1, 1,
      	-1, -1, -1, -1, -1, 1, -1, 1, 1, -1, 1, -1, 1, 1, 1, -1, -1, 1, -1, -1, -1, 1, 1, 1, -1, -1, -1, -1, -1, -1, -1))
    rolloff: '0'
    sync_word1: |
      [0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 1.4142135623730951, 0.0, 0.0, 0.0, -1.4142135623730951, 0.0, 0.0, 0.0, 1.4142135623730951, 0.0, 0.0, 0.0, 1.4142135623730951, 0.0, 0.0, 0.0, 1.4142135623730951, 0.0, 0.0, 0.0, -1.4142135623730951, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 1.4142135623730951, 0.0, 0.0, 0.0, 1.4142135623730951, 0.0, 0.0, 0.0, 1.4142135623730951, 0.0, 0.0, 0.0, -1.4142135623730951, 0.0, 0.0, 0.0, 1.4142135623730951, 0.0, 0.0, 0.0, 1.4142135623730951, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0]
    sync_word2: |
      [0, 0, 0, 0, 0, 0, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 0, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 1, -1, 1, -1, -1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0]
  states: {}
- name: doa4rfc_zmq_if_sink_0
  id: doa4rfc_zmq_if_sink
  parameters:
    endpoint: tcp://127.0.0.1:5554
    num_channels: '4'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_factor
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_factor
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_factor
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_2
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_factor
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.01'
    decim: interp_factor
    gain: '1'
    ntaps: rrc_taps_ch0*f_s
    samp_rate: f_s
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.01'
    decim: interp_factor
    gain: '1'
    ntaps: rrc_taps_ch1*f_s
    samp_rate: f_s
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.01'
    decim: interp_factor
    gain: '1'
    ntaps: rrc_taps_ch2*f_s
    samp_rate: f_s
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_1_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.01'
    decim: interp_factor
    gain: '1'
    ntaps: rrc_taps_ch3*f_s
    samp_rate: f_s
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0_0_0, '1']
- [analog_noise_source_x_0_1, '0', blocks_add_xx_0_0, '1']
- [analog_noise_source_x_0_1_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0_1, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0_2, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_add_xx_0_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_add_xx_0_0_0, '0', interp_fir_filter_xxx_0_2, '0']
- [blocks_add_xx_0_0_0_0, '0', interp_fir_filter_xxx_0_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', doa4rfc_zmq_if_sink_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', doa4rfc_zmq_if_sink_0, '1']
- [blocks_multiply_conjugate_cc_0_1, '0', doa4rfc_zmq_if_sink_0, '3']
- [blocks_multiply_conjugate_cc_0_2, '0', doa4rfc_zmq_if_sink_0, '2']
- [blocks_multiply_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '1']
- [blocks_stream_mux_0, '0', blocks_multiply_xx_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_ofdm_tx_0, '0', blocks_stream_mux_0, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [interp_fir_filter_xxx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [interp_fir_filter_xxx_0_1, '0', root_raised_cosine_filter_0_1_0, '0']
- [interp_fir_filter_xxx_0_2, '0', root_raised_cosine_filter_0_1, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [root_raised_cosine_filter_0_1, '0', blocks_multiply_conjugate_cc_0_2, '0']
- [root_raised_cosine_filter_0_1_0, '0', blocks_multiply_conjugate_cc_0_1, '0']
- [root_raised_cosine_filter_0_1_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
